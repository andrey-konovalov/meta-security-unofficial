include optee-os.inc

PR="r0"
PV="1.1.0+git"

SRCREV = "c042fbefb52822b8f1c681d49e272092edd10b0d"
