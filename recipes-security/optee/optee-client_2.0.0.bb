include optee-client.inc

PR="r0"
PV="2.0.0+git"

SRCREV = "fcd1014947e784ca8d618035bcb999f9151096b0"
