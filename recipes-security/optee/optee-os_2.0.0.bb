include optee-os.inc

PR="r0"
PV="2.0.0+git"

SRCREV = "d1a3c3c5f44fe8e5f41c89035e89615390060bde"
