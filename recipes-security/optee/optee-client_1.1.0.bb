include optee-client.inc

PR="r0"
PV="1.1.0+git"

SRCREV = "0b0d237779de6982451f6f5971b7106e459a2958"
